Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-27T09:46:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 27 09:46:05 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f48b3eef-d9a2-4950-9563-5773c556083c\78357a1f-7d72-4c42-ab30-0ff1283ad0ec\ifc * Database version: 5507 * Database creation date: Fri Jan 27 09:46:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 27 09:46:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 27 09:46:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12159930_EU1_H2861BP_GRGR:22286135_EU1_12159930_H2861BP_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22286135_EU1_12159930_H2861BP_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22286135_EU1_12159930_H2861BP_GRGR
Type - Pset_ProvisionForVoid - Depth: 568 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 596 mm

# IfcDistributionPort, Port_353918
Description: Flow; FlowDirection: SOURCEANDSINK
